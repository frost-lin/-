# Keil uVision project TEST.uvprojx, settings and files
target TEST (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\CMSIS\CoreSupport;..\..\CMSIS\DeviceSupport;..\..\FWlib\inc;..\..\USER;..\..\USER\CPU
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MDK_STARTUP
    ../../CMSIS/DeviceSupport/startup/: startup_stm32f10x_hd.s
    ../../FWlib/src/: stm32f10x_spi.c
  group CMSIS
    ../../CMSIS/CoreSupport/: core_cm3.c
    ../../CMSIS/DeviceSupport/: system_stm32f10x.c
  group USER
    ../../USER/: main.c sys.c delay.c usart.c adc.c spi.c mpu6050.c mpuiic.c dma.c timer.c IO.c system.c
  group STM32_LIB
    ../../FWlib/src/: misc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_gpio.c stm32f10x_dma.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dac.c
